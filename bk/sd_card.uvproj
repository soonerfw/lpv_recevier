# Keil uVision project sd_card.uvproj, settings and files
target st7735 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: st7735
  AfterMake: fromelf --bin --output .\rvmdk\st7735.bin .\rvmdk\st7735.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 ENABLE_LFN
  c misc: --c99
  c include: .\TivaWare;.\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\st7735.sct
  link misc: --entry Reset_Handler
  group Startup
    ./Startup/: startup_rvmdk.S
  group Source
    ./sources/: sd_card.c
  group Libraries
    ./TivaWare/driverlib/rvmdk/: driverlib.lib
  group TivaWare utils
    ./TivaWare/utils/: uartstdio.c cmdline.c
  group fatfs
    ./third_party/fatfs/src/: ff.c
    ./third_party/fatfs/port/: mmc-ek-tm4c123g.c
    ./third_party/fatfs/src/option/: cc932.c
  group Documentation
    ./: readme.txt

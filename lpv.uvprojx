# Keil uVision project lpv.uvprojx, settings and files
target lpv (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: st7735
  AfterMake: fromelf --bin --output .\rvmdk\st7735.bin .\rvmdk\st7735.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 ENABLE_LFN
  c misc: --c99
  c include: .\TivaWare;.\third_party;.\sources;.\grlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\lpv.sct
  link misc: --entry Reset_Handler
  group Startup
    ./Startup/: startup_rvmdk.S
  group Source
    ./sources/: funcs.c timercmd.c fontview.c
    ./drivers/: Kentec320x240x16_ssd2119_spi.c frame.c
    ./TivaWare/utils/: ustdlib.c
  group Libraries
    ./TivaWare/driverlib/rvmdk/: driverlib.lib grlib.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.3.0
